v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
B 2 1210 -2040 2010 -1640 {flags=graph
y1=-0.22
y2=0.22
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-2.156381e-07
x2=-1.806381e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node=VLO
color=12
dataset=-1
unitx=1
logx=0
logy=0
}
B 2 130 -2040 930 -1640 {flags=graph
y1=0.004
y2=0.014
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-2.156381e-07
x2=-1.806381e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node=VRF
color=7
dataset=-1
unitx=1
logx=0
logy=0
}
B 2 1920 -1250 2720 -850 {flags=graph
y1=0.98762374
y2=0.98831093
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-2.156381e-07
x2=-1.806381e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node=OUT
color=6
dataset=-1
unitx=1
logx=0
logy=0
}
B 2 640 -810 1440 -410 {flags=graph
y1=1.3
y2=1.4
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-2.156381e-07
x2=-1.806381e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node="IFP
IFN"
color="8 12"
dataset=-1
unitx=1
logx=0
logy=0
}
N 420 -1440 420 -1400 {lab=GND}
N 420 -1540 420 -1500 {lab=VCC}
N 1070 -1670 1070 -1630 {lab=VCC}
N 1070 -1310 1070 -1270 {lab=GND}
N 1230 -1540 1230 -1500 {lab=LOP}
N 910 -1540 910 -1500 {lab=RFP}
N 910 -1440 910 -1400 {lab=RFN}
N 830 -1440 910 -1440 {lab=RFN}
N 1230 -1440 1230 -1400 {lab=LON}
N 410 -1060 410 -1020 {lab=VCCDUMMY}
N 410 -960 410 -920 {lab=GND}
N 1270 -880 1270 -870 {lab=GND}
N 1270 -1110 1310 -1110 {lab=#net1}
N 1270 -990 1310 -990 {lab=#net2}
N 1230 -1110 1270 -1110 {lab=#net1}
N 1440 -1240 1560 -1240 {lab=OUT}
N 1270 -990 1270 -940 {lab=#net2}
N 1230 -990 1270 -990 {lab=#net2}
N 1270 -1240 1380 -1240 {lab=#net1}
N 1560 -1240 1560 -1050 {lab=OUT}
N 1270 -1240 1270 -1110 {lab=#net1}
N 1120 -1110 1170 -1110 {lab=#net3}
N 490 -1440 490 -1400 {lab=GND}
N 490 -1540 490 -1500 {lab=VDD}
N 1730 -960 1730 -870 {lab=GND}
N 1730 -1050 1730 -1020 {lab=OUT}
N 1020 -990 1170 -990 {lab=#net4}
N 1020 -1110 1020 -990 {lab=#net4}
N 1520 -1050 1560 -1050 {lab=OUT}
N 1730 -1050 1800 -1050 {lab=OUT}
N 1680 -1050 1680 -1020 {lab=OUT}
N 1560 -1050 1590 -1050 {lab=OUT}
N 1680 -1050 1730 -1050 {lab=OUT}
N 1650 -1050 1680 -1050 {lab=OUT}
N 1020 -1310 1020 -1170 {lab=IFP}
N 1120 -1310 1120 -1170 {lab=IFN}
N 1820 -1340 1820 -1330 {lab=IFN}
N 1660 -1340 1660 -1330 {lab=IFP}
N 1690 -1380 1720 -1380 {lab=GND}
N 1720 -1380 1720 -1260 {lab=GND}
N 1660 -1260 1720 -1260 {lab=GND}
N 1660 -1270 1660 -1260 {lab=GND}
N 1760 -1380 1790 -1380 {lab=GND}
N 1760 -1380 1760 -1260 {lab=GND}
N 1820 -1270 1820 -1260 {lab=GND}
N 1740 -1300 1790 -1300 {lab=VDD}
N 1740 -1420 1740 -1300 {lab=VDD}
N 1740 -1420 1820 -1420 {lab=VDD}
N 1820 -1420 1820 -1410 {lab=VDD}
N 1690 -1300 1740 -1300 {lab=VDD}
N 1660 -1420 1740 -1420 {lab=VDD}
N 1660 -1420 1660 -1410 {lab=VDD}
N 1760 -1260 1820 -1260 {lab=GND}
N 1740 -1260 1760 -1260 {lab=GND}
N 1740 -1260 1740 -1220 {lab=GND}
N 1720 -1260 1740 -1260 {lab=GND}
N 1740 -1460 1740 -1420 {lab=VDD}
N 1820 -1340 1860 -1340 {lab=IFN}
N 1820 -1350 1820 -1340 {lab=IFN}
N 1620 -1340 1660 -1340 {lab=IFP}
N 1660 -1350 1660 -1340 {lab=IFP}
N 1230 -1500 1310 -1500 {lab=LOP}
N 1230 -1440 1310 -1440 {lab=LON}
N 830 -1500 910 -1500 {lab=RFP}
C {port_diff.sym} 1310 -1470 0 1 {name=P2 portnum=1 Z0=85 DCval=0 ACmag=0 ACphase=0 TRANval="SIN(0 \{VLO_PP\} \{FLO\} 0 0 \{THETALO\})"}
C {param.sym} 110 -1180 0 0 {name=s1 value="FRF=149.9G"}
C {param.sym} 110 -1150 0 0 {name=s3 value="THETARF=0"}
C {code.sym} 110 -1530 0 0 {name=AC only_toplevel=false title=AC value="
.PREPROCESS REPLACEGROUND TRUE
.AC LIN 101 100G 200G
.LIN FORMAT=TOUCHSTONE FILE=MIXER+IFAMP_TBAC.s2p LINTYPE=S DATAFORMAT=MA
"
spice_ignore=true}
C {code.sym} 230 -1530 0 0 {name=TRAN only_toplevel=false title=TRAN value="
.PREPROCESS REPLACEGROUND TRUE
.TRAN 5u 40n 5n
.MEASURE TRAN VIF EQN V(IFP,IFN)
.MEASURE TRAN VRF EQN V(RFP,RFN)
.MEASURE TRAN VLO EQN V(LOP,LON)
.MEASURE TRAN ICCM EQN I(V1)
.MEASURE TRAN ICCM_RMS RMS I(V1)

.PRINT TRAN FORMAT=RAW FILE=MIXER+IFAMP_TBTRAN.raw V(*) I(*) ICCM ICCM_RMS VIF VRF VLO
.FOUR 100Meg V(IFP,IFN)
.FOUR 100Meg V(OUT)
"
}
C {vsource.sym} 420 -1470 0 0 {name=V1 value=2.4 savecurrent=false}
C {vdd.sym} 420 -1540 0 0 {name=l10 lab=VCC}
C {launcher.sym} 800 -1050 0 0 {name=h5
descr="load waves TRAN" 
tclcommand="xschem raw_read $netlist_dir/MIXER+IFAMP_TBTRAN.raw tran"
}
C {launcher.sym} 800 -1090 0 0 {name=h2
descr=SimulateXyce
tclcommand="
# Setup the default simulation commands if not already set up
# for example by already launched simulations.
set_sim_defaults

# Change the Xyce command. In the spice category there are currently
# 5 commands (0, 1, 2, 3, 4). Command 3 is the Xyce batch
# you can get the number by querying $sim(spice,n)
set sim(spice,3,cmd) \{Xyce -plugin $env(PDK_ROOT)/$env(PDK)/libs.tech/xyce/plugins/Xyce_Plugin_PSP103_VA.so \\"$N\\"\}

# change the simulator to be used (Xyce)
set sim(spice,default) 3

# run netlist and simulation
xschem netlist
simulate
"}
C {port_diff.sym} 830 -1470 0 0 {name=P4 portnum=2 Z0=85 DCval=0 ACmag=0 ACphase=0 TRANval="SIN(0 \{VRF_PP\} \{FRF\} 0 0 \{THETARF\})"}
C {param.sym} 520 -1310 0 0 {name=s6 value="PLO_DBM=-6
*.STEP LIN PLO_DBM -20 20 5"}
C {param.sym} 520 -1270 0 0 {name=s7 value="PLO=\{10**\{0.1*\{PLO_DBM\}\}/1000\}"}
C {param.sym} 520 -1240 0 0 {name=s8 value="VLO_RMS=\{SQRT(\{PLO\}*85)\}"}
C {param.sym} 520 -1210 0 0 {name=s9 value="VLO_PP=\{SQRT(2)*2*\{VLO_RMS\}\}"}
C {param.sym} 110 -1310 0 0 {name=s10 value="PRF_DBM=-130
*.STEP LIN PRF_DBM -130 0 10"}
C {param.sym} 110 -1270 0 0 {name=s11 value="PRF=\{10**\{0.1*\{PRF_DBM\}\}/1000\}"}
C {param.sym} 110 -1240 0 0 {name=s12 value="VRF_RMS=\{SQRT(\{PRF\}*85)\}"}
C {param.sym} 110 -1210 0 0 {name=s13 value="VRF_PP=\{SQRT(2)*2*\{VRF_RMS\}\}"}
C {param.sym} 520 -1180 0 0 {name=s14 value="FLO=150G"}
C {param.sym} 520 -1150 0 0 {name=s16 value="THETALO=0"}
C {MIXER.sym} 1070 -1470 0 0 {name=x1}
C {vdd.sym} 1070 -1670 0 0 {name=l1 lab=VCC}
C {gnd.sym} 1070 -1270 0 0 {name=l2 lab=GND}
C {lab_pin.sym} 1020 -1180 0 0 {name=p1 sig_type=std_logic lab=IFP}
C {lab_pin.sym} 1120 -1180 2 0 {name=p3 sig_type=std_logic lab=IFN}
C {gnd.sym} 420 -1400 0 0 {name=l3 lab=GND}
C {title.sym} 160 -30 0 0 {name=l4 author="Ghaith AL SABAGH" lock=true}
C {lab_pin.sym} 1230 -1400 3 0 {name=p5 sig_type=std_logic lab=LON}
C {lab_pin.sym} 910 -1400 3 0 {name=p6 sig_type=std_logic lab=RFN}
C {lab_pin.sym} 910 -1540 1 0 {name=p7 sig_type=std_logic lab=RFP}
C {lab_pin.sym} 1230 -1540 1 0 {name=p8 sig_type=std_logic lab=LOP}
C {code.sym} -20 -1530 0 0 {name=DC only_toplevel=false value="
.PREPROCESS REPLACEGROUND TRUE
.DC LIN V2 -1 1 1
.PRINT DC FORMAT=RAW FILE=MIXER+IFAMP_TBDC.raw V(*) I(*) 
"
spice_ignore=true}
C {launcher.sym} 800 -1010 0 0 {name=h1
descr="load waves DC" 
tclcommand="xschem raw_read $netlist_dir/MIXER+IFAMP_TBDC.raw dc"
}
C {vsource.sym} 410 -990 0 0 {name=V2 value=2.4 savecurrent=false}
C {vdd.sym} 410 -1060 0 0 {name=l13 lab=VCCDUMMY}
C {gnd.sym} 410 -920 0 0 {name=l14 lab=GND}
C {vdd.sym} 1410 -920 2 0 {name=l6 lab=VDD
}
C {lab_pin.sym} 1800 -1050 0 1 {name=p9 sig_type=std_logic lab=OUT
}
C {gnd.sym} 1730 -870 0 0 {name=l7 lab=GND
}
C {gnd.sym} 1410 -1180 2 1 {name=l8 lab=GND
}
C {IFAMP.sym} 1410 -1050 2 1 {name=x2
}
C {vsource.sym} 490 -1470 0 0 {name=V3 value=2.0 savecurrent=false}
C {vdd.sym} 490 -1540 0 0 {name=l11 lab=VDD}
C {gnd.sym} 490 -1400 0 0 {name=l12 lab=GND}
C {res.sym} 1730 -990 0 0 {name=R6
value=1MEG
footprint=1206
device=resistor
m=1}
C {simulator_commands_shown.sym} 130 -2160 0 0 {name=Libs_Xyce1
simulator=xyce
only_toplevel=false 
value="tcleval(
.lib $::SG13G2_MODELS_XYCE/cornerHBT.lib hbt_typ
.lib $::SG13G2_MODELS_XYCE/cornerCAP.lib cap_typ
.lib $::SG13G2_MODELS_XYCE/cornerRES.lib res_typ
.include $::SG13G2_MODELS_XYCE/sg13g2_esd.lib
)"}
C {simulator_commands_shown.sym} 920 -2160 0 0 {name=Libs_ngspice1
simulator=ngspice
only_toplevel=false 
value="tcleval(
.lib $::SG13G2_MODELS/cornerHBT.lib hbt_typ
.lib $::SG13G2_MODELS/cornerCAP.lib cap_typ
.lib $::SG13G2_MODELS/cornerRES.lib res_typ
.include $::SG13G2_MODELS/sg13g2_esd.lib
)"}
C {res.sym} 1200 -1110 1 0 {name=R7
value=10k
footprint=1206
device=resistor
m=1}
C {res.sym} 1200 -990 1 0 {name=R8
value=10k
footprint=1206
device=resistor
m=1}
C {res.sym} 1410 -1240 1 0 {name=R9
value=200k
footprint=1206
device=resistor
m=1}
C {ammeter.sym} 1020 -1140 0 1 {name=Vifp savecurrent=true spice_ignore=0}
C {ammeter.sym} 1120 -1140 0 1 {name=Vifn savecurrent=true spice_ignore=0}
C {capa.sym} 1680 -990 0 0 {name=C1
m=1
value=10p
footprint=1206
device="ceramic capacitor"
spice_ignore=true}
C {gnd.sym} 1680 -960 0 0 {name=l15 lab=GND
spice_ignore=true}
C {ind.sym} 1620 -1050 1 0 {name=L16
m=1
value=1n
footprint=1206
device=inductor
spice_ignore=short}
C {gnd.sym} 1270 -870 0 0 {name=l17 lab=GND
}
C {res.sym} 1270 -910 2 0 {name=R11
value=417k
footprint=1206
device=resistor
m=1
}
C {sg13g2_pr/diodevss_4kv.sym} 1660 -1300 0 1 {name=D1
model=diodevss_4kv
spiceprefix=X
m=1
}
C {sg13g2_pr/diodevss_4kv.sym} 1820 -1300 0 0 {name=D2
model=diodevss_4kv
spiceprefix=X
m=1
}
C {sg13g2_pr/diodevdd_4kv.sym} 1660 -1380 0 1 {name=D3
model=diodevdd_4kv
m=1
spiceprefix=X
}
C {sg13g2_pr/diodevdd_4kv.sym} 1820 -1380 0 0 {name=D4
model=diodevdd_4kv
m=1
spiceprefix=X
}
C {gnd.sym} 1740 -1220 0 0 {name=l18 lab=GND}
C {vdd.sym} 1740 -1460 0 0 {name=l19 lab=VDD}
C {lab_pin.sym} 1860 -1340 2 0 {name=p12 sig_type=std_logic lab=IFN}
C {lab_pin.sym} 1620 -1340 0 0 {name=p13 sig_type=std_logic lab=IFP}
C {launcher.sym} 800 -970 0 0 {name=h3
descr="load waves TRAN REF" 
tclcommand="xschem raw_read $netlist_dir/MIXER+IFAMP_TBTRAN.raw tran"
}
