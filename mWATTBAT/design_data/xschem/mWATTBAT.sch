v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 430 -1100 430 -1050 {lab=OUT1P}
N 430 -1100 470 -1100 {lab=OUT1P}
N 690 -1100 690 -1050 {lab=OUT2P}
N 690 -1100 730 -1100 {lab=OUT2P}
N 950 -1100 990 -1100 {lab=OUT3P}
N 430 -1010 430 -960 {lab=OUT1N}
N 430 -960 470 -960 {lab=OUT1N}
N 690 -1010 690 -960 {lab=OUT2N}
N 690 -960 730 -960 {lab=OUT2N}
N 950 -960 990 -960 {lab=OUT3N}
N 1510 -1010 1590 -1010 {lab=LOP}
N 1510 -950 1590 -950 {lab=LON}
N 1210 -1060 1250 -1060 {lab=OUT4P}
N 1210 -1000 1250 -1000 {lab=OUT4N}
N 1210 -1060 1210 -1050 {lab=OUT4P}
N 1210 -1010 1210 -1000 {lab=OUT4N}
N 950 -1100 950 -1050 {lab=OUT3P}
N 950 -1010 950 -960 {lab=OUT3N}
N 1590 -1030 1590 -1010 {lab=LOP}
N 1590 -1030 1670 -1030 {lab=LOP}
N 1590 -950 1590 -930 {lab=LON}
N 1590 -930 1670 -930 {lab=LON}
N 1510 -1110 1590 -1110 {lab=#net1}
N 1510 -1050 1650 -1050 {lab=#net2}
N 1990 -1030 2030 -1030 {lab=#net3}
N 1990 -930 2090 -930 {lab=#net4}
N 1970 -680 2050 -680 {lab=#net5}
N 1970 -680 1970 -660 {lab=#net5}
N 1970 -720 1970 -680 {lab=#net5}
N 310 -1550 330 -1550 {lab=1V65}
N 570 -1550 590 -1550 {lab=2V4}
N 2150 -810 2170 -810 {lab=2V0}
N 2150 -840 2150 -810 {lab=2V0}
N 90 -1030 110 -1030 {lab=RFIN}
N 110 -1050 110 -1030 {lab=RFIN}
N 110 -1030 210 -1030 {lab=RFIN}
N 1700 -390 1920 -390 {lab=#net6}
N 2260 -620 2300 -620 {lab=IFOUTP}
N 1700 -720 1700 -560 {lab=#net6}
N 2950 -640 2950 -620 {lab=IFOUTP}
N 2300 -620 2460 -620 {lab=IFOUTP}
N 310 -1590 310 -1550 {lab=1V65}
N 570 -1590 570 -1550 {lab=2V4}
N 2030 -1590 2030 -1030 {lab=#net3}
N 2090 -1590 2090 -930 {lab=#net4}
N 1650 -1580 1650 -1050 {lab=#net2}
N 1590 -1580 1590 -1110 {lab=#net1}
N 1830 -1350 1830 -1140 {lab=2V4}
N 570 -710 1830 -710 {lab=GND}
N 310 -1180 830 -1180 {lab=1V65}
N 310 -880 830 -880 {lab=GND}
N 570 -800 1090 -800 {lab=GND}
N 570 -1260 1090 -1260 {lab=2V4}
N 570 -1350 570 -1260 {lab=2V4}
N 2150 -430 2150 -230 {lab=GND}
N 1090 -900 1090 -800 {lab=GND}
N 1090 -1260 1090 -1160 {lab=2V4}
N 830 -900 830 -880 {lab=GND}
N 830 -1180 830 -1160 {lab=1V65}
N 570 -1260 570 -1160 {lab=2V4}
N 570 -900 570 -800 {lab=GND}
N 310 -900 310 -880 {lab=GND}
N 310 -1180 310 -1160 {lab=1V65}
N 1880 -780 1970 -780 {lab=IFP}
N 1700 -780 1780 -780 {lab=IFN}
N 2150 -810 2150 -750 {lab=2V0}
N 2150 -490 2150 -430 {lab=GND}
N 2300 -620 2300 -390 {lab=IFOUTP}
N 1700 -560 1700 -390 {lab=#net6}
N 570 -800 570 -710 {lab=GND}
N 1830 -820 1830 -710 {lab=GND}
N 1980 -390 2300 -390 {lab=IFOUTP}
N 1970 -430 2150 -430 {lab=GND}
N 1970 -600 1970 -430 {lab=GND}
N 1700 -560 2050 -560 {lab=#net6}
N 1550 -1580 1590 -1580 {lab=#net1}
N 1550 -1640 1550 -1580 {lab=#net1}
N 1650 -1580 1690 -1580 {lab=#net2}
N 1690 -1640 1690 -1580 {lab=#net2}
N 2030 -1590 2040 -1590 {lab=#net3}
N 2040 -1640 2040 -1590 {lab=#net3}
N 2080 -1640 2080 -1590 {lab=#net4}
N 2080 -1590 2090 -1590 {lab=#net4}
N 1360 -2110 1650 -2110 {lab=ANTTN}
N 2130 -1890 2130 -1830 {lab=ANTRP}
N 2030 -2110 2370 -2110 {lab=ANTRN}
N 1990 -1890 1990 -1830 {lab=ANTRN}
N 1590 -2050 1590 -1890 {lab=ANTTP}
N 1360 -2050 1590 -2050 {lab=ANTTP}
N 1650 -2110 1650 -1890 {lab=ANTTN}
N 1640 -1890 1650 -1890 {lab=ANTTN}
N 1640 -1890 1640 -1830 {lab=ANTTN}
N 1590 -1890 1600 -1890 {lab=ANTTP}
N 1600 -1890 1600 -1830 {lab=ANTTP}
N 1990 -1890 2030 -1890 {lab=ANTRN}
N 2090 -1890 2130 -1890 {lab=ANTRP}
N 2090 -2050 2090 -1890 {lab=ANTRP}
N 2090 -2050 2370 -2050 {lab=ANTRP}
N 2030 -2110 2030 -1890 {lab=ANTRN}
N 1430 -1740 1430 -1350 {lab=2V4}
N 1430 -1350 1830 -1350 {lab=2V4}
N 2190 -1730 2250 -1730 {lab=2V4}
N 2250 -1730 2250 -1350 {lab=2V4}
N 1830 -1350 2250 -1350 {lab=2V4}
N 1430 -1740 1490 -1740 {lab=2V4}
N 1750 -1740 1840 -1740 {lab=#net7}
N 1840 -1740 1840 -1730 {lab=#net7}
N 1840 -1730 1930 -1730 {lab=#net7}
N 1840 -1730 1840 -1540 {lab=#net7}
N 1840 -1540 2300 -1540 {lab=#net7}
N 2320 -1540 2320 -230 {lab=GND}
N 400 -1050 430 -1050 {lab=OUT1P}
N 660 -1050 690 -1050 {lab=OUT2P}
N 920 -1050 950 -1050 {lab=OUT3P}
N 1180 -1050 1210 -1050 {lab=OUT4P}
N 1180 -1010 1210 -1010 {lab=OUT4N}
N 920 -1010 950 -1010 {lab=OUT3N}
N 660 -1010 690 -1010 {lab=OUT2N}
N 400 -1010 430 -1010 {lab=OUT1N}
N 280 -1550 280 -1510 {lab=1V65}
N 280 -1550 310 -1550 {lab=1V65}
N 310 -1490 310 -1180 {lab=1V65}
N 280 -1450 280 -1420 {lab=GND}
N 540 -1550 540 -1510 {lab=2V4}
N 540 -1550 570 -1550 {lab=2V4}
N 540 -1450 540 -1420 {lab=GND}
N 570 -1430 570 -1350 {lab=2V4}
N 310 -1490 330 -1490 {lab=1V65}
N 310 -1550 310 -1490 {lab=1V65}
N 570 -1490 590 -1490 {lab=2V4}
N 570 -1550 570 -1490 {lab=2V4}
N 570 -1430 590 -1430 {lab=2V4}
N 570 -1490 570 -1430 {lab=2V4}
N 710 -1370 710 -1350 {lab=2V4}
N 570 -1350 710 -1350 {lab=2V4}
N 770 -1370 770 -1350 {lab=2V4}
N 710 -1350 770 -1350 {lab=2V4}
N 830 -1370 830 -1350 {lab=2V4}
N 770 -1350 830 -1350 {lab=2V4}
N 830 -1350 1430 -1350 {lab=2V4}
N 2040 -810 2070 -810 {lab=GND}
N 2130 -810 2150 -810 {lab=2V0}
N 2490 -680 2520 -680 {lab=GND}
N 2520 -680 2520 -520 {lab=GND}
N 2460 -520 2520 -520 {lab=GND}
N 2460 -530 2460 -520 {lab=GND}
N 2490 -560 2540 -560 {lab=2V0}
N 2540 -720 2540 -560 {lab=2V0}
N 2460 -720 2540 -720 {lab=2V0}
N 2460 -720 2460 -710 {lab=2V0}
N 2460 -840 2460 -720 {lab=2V0}
N 2150 -840 2460 -840 {lab=2V0}
N 2150 -850 2150 -840 {lab=2V0}
N 2460 -520 2460 -430 {lab=GND}
N 2150 -430 2460 -430 {lab=GND}
N 2460 -620 2460 -590 {lab=IFOUTP}
N 2460 -650 2460 -620 {lab=IFOUTP}
N 2950 -620 2980 -620 {lab=IFOUTP}
N 570 -230 980 -230 {lab=GND}
N 1520 -230 1520 -210 {lab=GND}
N 980 -230 980 -210 {lab=GND}
N 1040 -230 1040 -210 {lab=GND}
N 1100 -230 1100 -210 {lab=GND}
N 1160 -230 1160 -210 {lab=GND}
N 1220 -230 1220 -210 {lab=GND}
N 1040 -230 1100 -230 {lab=GND}
N 1280 -230 1280 -210 {lab=GND}
N 1340 -230 1340 -210 {lab=GND}
N 1400 -230 1400 -210 {lab=GND}
N 1460 -230 1460 -210 {lab=GND}
N 2950 -380 2950 -360 {lab=IFN}
N 2950 -490 2950 -470 {lab=IFP}
N 1100 -230 1160 -230 {lab=GND}
N 1160 -230 1220 -230 {lab=GND}
N 980 -230 1040 -230 {lab=GND}
N 1460 -230 1520 -230 {lab=GND}
N 1220 -230 1280 -230 {lab=GND}
N 1280 -230 1340 -230 {lab=GND}
N 1340 -230 1400 -230 {lab=GND}
N 1400 -230 1460 -230 {lab=GND}
N 1780 -360 2840 -360 {lab=IFN}
N 2680 -530 2710 -530 {lab=GND}
N 2650 -370 2710 -370 {lab=GND}
N 2650 -380 2650 -370 {lab=GND}
N 2680 -410 2730 -410 {lab=2V0}
N 2730 -570 2730 -410 {lab=2V0}
N 2650 -570 2730 -570 {lab=2V0}
N 2650 -570 2650 -560 {lab=2V0}
N 2650 -470 2650 -440 {lab=IFP}
N 2650 -500 2650 -470 {lab=IFP}
N 1880 -470 2650 -470 {lab=IFP}
N 2870 -420 2900 -420 {lab=GND}
N 2900 -420 2900 -260 {lab=GND}
N 2840 -260 2900 -260 {lab=GND}
N 2840 -270 2840 -260 {lab=GND}
N 2870 -300 2920 -300 {lab=2V0}
N 2920 -460 2920 -300 {lab=2V0}
N 2840 -460 2920 -460 {lab=2V0}
N 2840 -460 2840 -450 {lab=2V0}
N 2840 -360 2840 -330 {lab=IFN}
N 2840 -390 2840 -360 {lab=IFN}
N 2950 -470 2980 -470 {lab=IFP}
N 2950 -360 2980 -360 {lab=IFN}
N 2710 -530 2710 -370 {lab=GND}
N 2710 -370 2710 -230 {lab=GND}
N 2320 -230 2710 -230 {lab=GND}
N 210 -230 310 -230 {lab=GND}
N 410 -230 570 -230 {lab=GND}
N 2710 -230 2840 -230 {lab=GND}
N 2840 -260 2840 -230 {lab=GND}
N 2650 -840 2650 -570 {lab=2V0}
N 2650 -840 2840 -840 {lab=2V0}
N 2840 -840 2840 -460 {lab=2V0}
N 2460 -840 2650 -840 {lab=2V0}
N 2650 -470 2950 -470 {lab=IFP}
N 2840 -360 2950 -360 {lab=IFN}
N 310 -880 310 -230 {lab=GND}
N 570 -710 570 -230 {lab=GND}
N 1520 -230 2150 -230 {lab=GND}
N 2150 -230 2320 -230 {lab=GND}
N 2460 -620 2950 -620 {lab=IFOUTP}
N 1880 -780 1880 -470 {lab=IFP}
N 1880 -820 1880 -780 {lab=IFP}
N 1780 -780 1780 -360 {lab=IFN}
N 1780 -820 1780 -780 {lab=IFN}
N 210 -230 210 -210 {lab=GND}
N 90 -230 210 -230 {lab=GND}
N 310 -230 310 -210 {lab=GND}
N 410 -230 410 -210 {lab=GND}
N 310 -230 410 -230 {lab=GND}
N 410 -150 410 -130 {lab=#net8}
N 310 -130 410 -130 {lab=#net8}
N 310 -150 310 -130 {lab=#net8}
N 210 -130 310 -130 {lab=#net8}
N 210 -150 210 -130 {lab=#net8}
N 310 -130 310 -110 {lab=#net8}
C {title.sym} 160 -30 0 0 {name=l1 author="Ghaith AL SABAGH" lock=true}
C {WILKINSON.sym} 1380 -1030 0 0 {name=x5}
C {lab_wire.sym} 1530 -1010 0 1 {name=p4 sig_type=std_logic lab=LOP}
C {lab_wire.sym} 1530 -950 0 1 {name=p5 sig_type=std_logic lab=LON}
C {lab_wire.sym} 1360 -2050 0 1 {name=p6 sig_type=std_logic lab=ANTTP}
C {lab_wire.sym} 1360 -2110 0 1 {name=p7 sig_type=std_logic lab=ANTTN}
C {lab_wire.sym} 1210 -1060 0 1 {name=p8 sig_type=std_logic lab=OUT4P}
C {lab_wire.sym} 1210 -1000 0 1 {name=p9 sig_type=std_logic lab=OUT4N}
C {lab_wire.sym} 950 -1100 0 1 {name=p10 sig_type=std_logic lab=OUT3P}
C {lab_wire.sym} 950 -960 0 1 {name=p11 sig_type=std_logic lab=OUT3N}
C {lab_wire.sym} 690 -1100 0 1 {name=p12 sig_type=std_logic lab=OUT2P}
C {lab_wire.sym} 690 -960 0 1 {name=p13 sig_type=std_logic lab=OUT2N}
C {lab_wire.sym} 430 -1100 0 1 {name=p14 sig_type=std_logic lab=OUT1P}
C {lab_wire.sym} 430 -960 0 1 {name=p15 sig_type=std_logic lab=OUT1N}
C {lab_wire.sym} 150 -1030 0 1 {name=p16 sig_type=std_logic lab=RFIN}
C {MIXER.sym} 1830 -980 0 1 {name=x6}
C {IFAMP.sym} 2150 -620 0 0 {name=x7}
C {TRX.sym} 1280 -2080 3 0 {name=x8 GAIN=3}
C {TRX.sym} 2450 -2080 1 1 {name=x9 GAIN=3}
C {iopin.sym} 1280 -1880 1 0 {name=p19 lab=TXP}
C {iopin.sym} 2450 -1880 1 0 {name=p1 lab=TRP}
C {iopin.sym} 1280 -2280 3 0 {name=p2 lab=TXN}
C {iopin.sym} 2450 -2280 3 0 {name=p3 lab=TRN}
C {iopin.sym} 90 -1030 2 0 {name=p17 lab=RFIN}
C {iopin.sym} 2150 -850 3 0 {name=p26 lab=2V0}
C {iopin.sym} 570 -1590 3 0 {name=p30 lab=2V4}
C {iopin.sym} 310 -1590 3 0 {name=p31 lab=1V65}
C {simulator_commands_shown.sym} 160 -1750 0 0 {name=Libs_Xyce
simulator=xyce
only_toplevel=false 
value="tcleval(
.include $::SG13G2_MODELS_XYCE/sg13g2_bondpad.lib
.include $::SG13G2_MODELS_XYCE/sg13g2_esd.lib
.lib $::SG13G2_MODELS_XYCE/cornerRES.lib res_typ
)"}
C {simulator_commands_shown.sym} 160 -1890 0 0 {name=Libs_ngspice
simulator=ngspice
only_toplevel=false 
value="tcleval(
.include $::SG13G2_MODELS/sg13g2_bondpad.lib
.include $::SG13G2_MODELS/sg13g2_esd.lib
.lib $::SG13G2_MODELS/cornerRES.lib res_typ
)"}
C {iopin.sym} 2980 -620 2 1 {name=p18 lab=IFOUTP}
C {lab_wire.sym} 2370 -2050 0 0 {name=p22 sig_type=std_logic lab=ANTRP}
C {lab_wire.sym} 2370 -2110 0 0 {name=p24 sig_type=std_logic lab=ANTRN}
C {sg13g2_pr/bondpad.sym} 110 -1090 0 0 {name=X15
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} 2950 -680 0 0 {name=X16
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} 370 -1550 1 0 {name=X17
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} 630 -1550 1 0 {name=X18
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} 2210 -810 1 0 {name=X19
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {BALUN_MULT_10GSE_50GD.sym} 310 -1030 0 0 {name=x1}
C {RFAMP_50GD.sym} 570 -1030 0 0 {name=x2}
C {MULT_50GD_150GD.sym} 830 -1030 0 0 {name=x3}
C {RFAMP_150GD.sym} 1090 -1030 0 0 {name=x4}
C {TXAMP_150GD.sym} 1620 -1740 3 0 {name=x26}
C {RXAMP_150GD.sym} 2060 -1730 1 0 {name=x27}
C {sg13g2_pr/nmoscl_4.sym} 280 -1480 0 1 {name=D1
model=nmoscl_4
m=2
spiceprefix=X
}
C {iopin.sym} 280 -1420 3 1 {name=p20 lab=GND
}
C {sg13g2_pr/nmoscl_4.sym} 540 -1480 0 1 {name=D2
model=nmoscl_4
m=6
spiceprefix=X
}
C {iopin.sym} 540 -1420 3 1 {name=p21 lab=GND
}
C {sg13g2_pr/bondpad.sym} 370 -1490 1 0 {name=X20
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} 630 -1490 1 0 {name=X21
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} 630 -1430 1 0 {name=X22
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} 710 -1410 0 0 {name=X23
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} 770 -1410 0 0 {name=X24
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} 830 -1410 0 0 {name=X25
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/nmoscl_4.sym} 2100 -810 1 1 {name=D3
model=nmoscl_4
m=1
spiceprefix=X
}
C {iopin.sym} 2040 -810 0 1 {name=p23 lab=GND
}
C {sg13g2_pr/diodevdd_4kv.sym} 2460 -680 0 1 {name=D4
model=diodevdd_4kv
m=1
spiceprefix=X
}
C {sg13g2_pr/diodevss_4kv.sym} 2460 -560 0 1 {name=D5
model=diodevss_4kv
spiceprefix=X
m=1
}
C {sg13g2_pr/rppd.sym} 1950 -390 1 0 {name=R25
w=2.0e-6
l=71.25e-6
model=rppd
spiceprefix=X
b=20
m=1
}
C {sg13g2_pr/rppd.sym} 1970 -630 2 0 {name=R24
w=2.0e-6
l=89.64e-6
model=rppd
spiceprefix=X
b=34
m=1
}
C {sg13g2_pr/rppd.sym} 1700 -750 0 1 {name=R22
w=2.5e-6
l=11.255e-6
model=rppd
spiceprefix=X
b=6
m=1
}
C {sg13g2_pr/rppd.sym} 1970 -750 0 1 {name=R23
w=2.5e-6
l=11.255e-6
model=rppd
spiceprefix=X
b=6
m=1
}
C {iopin.sym} 90 -230 2 0 {name=p33 lab=GND
}
C {sg13g2_pr/bondpad.sym} 980 -170 2 0 {name=X10
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} 1520 -170 2 0 {name=X11
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} 1040 -170 2 0 {name=X12
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} 1100 -170 2 0 {name=X13
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} 1160 -170 2 0 {name=X14
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} 1220 -170 2 0 {name=X28
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} 1280 -170 2 0 {name=X29
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} 1340 -170 2 0 {name=X30
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} 1400 -170 2 0 {name=X31
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} 1460 -170 2 0 {name=X32
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} 2950 -530 0 0 {name=X33
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} 2950 -420 0 0 {name=X34
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/diodevdd_4kv.sym} 2650 -530 0 1 {name=D6
model=diodevdd_4kv
m=1
spiceprefix=X
}
C {sg13g2_pr/diodevss_4kv.sym} 2650 -410 0 1 {name=D7
model=diodevss_4kv
spiceprefix=X
m=1
}
C {sg13g2_pr/diodevdd_4kv.sym} 2840 -420 0 1 {name=D8
model=diodevdd_4kv
m=1
spiceprefix=X
}
C {sg13g2_pr/diodevss_4kv.sym} 2840 -300 0 1 {name=D9
model=diodevss_4kv
spiceprefix=X
m=1
}
C {iopin.sym} 2980 -470 2 1 {name=p25 lab=IFP}
C {iopin.sym} 2980 -360 2 1 {name=p27 lab=IFN}
C {sg13g2_pr/ptap1.sym} 210 -180 0 0 {name=R[26..35]
model=ptap1
spiceprefix=X
w=80e-6
l=80e-6}
C {sg13g2_pr/ptap1.sym} 310 -180 0 0 {name=R[36..69]
model=ptap1
spiceprefix=X
w=15e-6
l=15e-6}
C {sg13g2_pr/ptap1.sym} 410 -180 0 0 {name=R[70..97]
model=ptap1
spiceprefix=X
w=2e-6
l=2e-6}
C {sg13g2_pr/sub.sym} 310 -110 0 0 {name=l2 lab=sub!
}
