v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {Special Schematic for LVS} 140 -2420 0 0 2 2 {layer=12}
N 430 -1020 430 -970 {lab=#net1}
N 430 -1020 470 -1020 {lab=#net1}
N 690 -1020 690 -970 {lab=#net2}
N 690 -1020 730 -1020 {lab=#net2}
N 950 -1020 990 -1020 {lab=#net3}
N 430 -930 430 -880 {lab=#net4}
N 430 -880 470 -880 {lab=#net4}
N 690 -930 690 -880 {lab=#net5}
N 690 -880 730 -880 {lab=#net5}
N 950 -880 990 -880 {lab=#net6}
N 1510 -930 1590 -930 {lab=#net7}
N 1510 -870 1590 -870 {lab=#net8}
N 1210 -980 1250 -980 {lab=#net9}
N 1210 -920 1250 -920 {lab=#net10}
N 1210 -980 1210 -970 {lab=#net9}
N 1210 -930 1210 -920 {lab=#net10}
N 950 -1020 950 -970 {lab=#net3}
N 950 -930 950 -880 {lab=#net6}
N 1590 -950 1590 -930 {lab=#net7}
N 1590 -950 1670 -950 {lab=#net7}
N 1590 -870 1590 -850 {lab=#net8}
N 1590 -850 1670 -850 {lab=#net8}
N 1510 -1030 1590 -1030 {lab=#net11}
N 1510 -970 1650 -970 {lab=#net12}
N 1990 -950 2030 -950 {lab=#net13}
N 1990 -850 2090 -850 {lab=#net14}
N 1970 -600 2050 -600 {lab=#net15}
N 1970 -600 1970 -580 {lab=#net15}
N 1970 -640 1970 -600 {lab=#net15}
N 310 -1470 330 -1470 {lab=1V65}
N 570 -1500 590 -1500 {lab=2V4}
N 2150 -730 2170 -730 {lab=2V0}
N 2150 -770 2150 -730 {lab=2V0}
N 90 -950 110 -950 {lab=RFIN}
N 110 -970 110 -950 {lab=RFIN}
N 110 -950 210 -950 {lab=RFIN}
N 1700 -310 1920 -310 {lab=#net16}
N 2260 -540 2300 -540 {lab=IFOUT}
N 1700 -640 1700 -480 {lab=#net16}
N 570 -160 980 -160 {lab=sub!}
N 2950 -560 2950 -540 {lab=IFOUT}
N 1520 -160 1520 -140 {lab=sub!}
N 2300 -540 2460 -540 {lab=IFOUT}
N 310 -1510 310 -1470 {lab=1V65}
N 570 -1470 570 -1440 {lab=2V4}
N 2030 -1510 2030 -950 {lab=#net13}
N 2090 -1510 2090 -850 {lab=#net14}
N 1650 -1500 1650 -970 {lab=#net12}
N 1590 -1500 1590 -1030 {lab=#net11}
N 1830 -1270 1830 -1060 {lab=2V4}
N 570 -630 1830 -630 {lab=sub!}
N 310 -1100 830 -1100 {lab=1V65}
N 310 -800 830 -800 {lab=sub!}
N 570 -720 1090 -720 {lab=sub!}
N 570 -1180 1090 -1180 {lab=2V4}
N 570 -1270 570 -1180 {lab=2V4}
N 310 -800 310 -160 {lab=sub!}
N 980 -160 980 -140 {lab=sub!}
N 2150 -350 2150 -160 {lab=sub!}
N 1090 -820 1090 -720 {lab=sub!}
N 1090 -1180 1090 -1080 {lab=2V4}
N 830 -820 830 -800 {lab=sub!}
N 830 -1100 830 -1080 {lab=1V65}
N 570 -1180 570 -1080 {lab=2V4}
N 570 -630 570 -160 {lab=sub!}
N 570 -820 570 -720 {lab=sub!}
N 310 -820 310 -800 {lab=sub!}
N 310 -1100 310 -1080 {lab=1V65}
N 310 -1410 310 -1100 {lab=1V65}
N 1880 -700 1970 -700 {lab=IFP}
N 1780 -740 1780 -700 {lab=IFN}
N 1700 -700 1780 -700 {lab=IFN}
N 2150 -730 2150 -670 {lab=2V0}
N 2150 -410 2150 -350 {lab=sub!}
N 2300 -540 2300 -310 {lab=IFOUT}
N 1700 -480 1700 -310 {lab=#net16}
N 570 -720 570 -630 {lab=sub!}
N 1830 -740 1830 -630 {lab=sub!}
N 1980 -310 2300 -310 {lab=IFOUT}
N 1970 -350 2150 -350 {lab=sub!}
N 1970 -520 1970 -350 {lab=sub!}
N 1700 -480 2050 -480 {lab=#net16}
N 1550 -1500 1590 -1500 {lab=#net11}
N 1550 -1560 1550 -1500 {lab=#net11}
N 1650 -1500 1690 -1500 {lab=#net12}
N 1690 -1560 1690 -1500 {lab=#net12}
N 2030 -1510 2040 -1510 {lab=#net13}
N 2040 -1560 2040 -1510 {lab=#net13}
N 2080 -1560 2080 -1510 {lab=#net14}
N 2080 -1510 2090 -1510 {lab=#net14}
N 1360 -2030 1650 -2030 {lab=#net17}
N 2130 -1810 2130 -1750 {lab=#net18}
N 2030 -2030 2370 -2030 {lab=#net19}
N 1990 -1810 1990 -1750 {lab=#net19}
N 1590 -1970 1590 -1810 {lab=#net20}
N 1360 -1970 1590 -1970 {lab=#net20}
N 1650 -2030 1650 -1810 {lab=#net17}
N 1640 -1810 1650 -1810 {lab=#net17}
N 1640 -1810 1640 -1750 {lab=#net17}
N 1590 -1810 1600 -1810 {lab=#net20}
N 1600 -1810 1600 -1750 {lab=#net20}
N 1990 -1810 2030 -1810 {lab=#net19}
N 2090 -1810 2130 -1810 {lab=#net18}
N 2090 -1970 2090 -1810 {lab=#net18}
N 2090 -1970 2370 -1970 {lab=#net18}
N 2030 -2030 2030 -1810 {lab=#net19}
N 1430 -1660 1430 -1270 {lab=2V4}
N 1430 -1270 1830 -1270 {lab=2V4}
N 2190 -1650 2250 -1650 {lab=2V4}
N 2250 -1650 2250 -1270 {lab=2V4}
N 1830 -1270 2250 -1270 {lab=2V4}
N 1430 -1660 1490 -1660 {lab=2V4}
N 1750 -1660 1840 -1660 {lab=sub!}
N 1840 -1660 1840 -1650 {lab=sub!}
N 1840 -1650 1930 -1650 {lab=sub!}
N 1840 -1650 1840 -1460 {lab=sub!}
N 2320 -1460 2320 -160 {lab=sub!}
N 400 -970 430 -970 {lab=#net1}
N 660 -970 690 -970 {lab=#net2}
N 920 -970 950 -970 {lab=#net3}
N 1180 -970 1210 -970 {lab=#net9}
N 1180 -930 1210 -930 {lab=#net10}
N 920 -930 950 -930 {lab=#net6}
N 660 -930 690 -930 {lab=#net5}
N 400 -930 430 -930 {lab=#net4}
N 1040 -160 1040 -140 {lab=sub!}
N 1100 -160 1100 -140 {lab=sub!}
N 1160 -160 1160 -140 {lab=sub!}
N 1220 -160 1220 -140 {lab=sub!}
N 1040 -160 1100 -160 {lab=sub!}
N 1280 -160 1280 -140 {lab=sub!}
N 1340 -160 1340 -140 {lab=sub!}
N 1400 -160 1400 -140 {lab=sub!}
N 1460 -160 1460 -140 {lab=sub!}
N 570 -1440 590 -1440 {lab=2V4}
N 570 -1440 570 -1380 {lab=2V4}
N 570 -1380 590 -1380 {lab=2V4}
N 570 -1320 570 -1270 {lab=2V4}
N 570 -1510 570 -1500 {lab=2V4}
N 570 -1320 590 -1320 {lab=2V4}
N 570 -1380 570 -1320 {lab=2V4}
N 2950 -310 2950 -290 {lab=IFN}
N 2950 -420 2950 -400 {lab=IFP}
N 790 -1270 1430 -1270 {lab=2V4}
N 790 -1290 790 -1270 {lab=2V4}
N 730 -1270 790 -1270 {lab=2V4}
N 730 -1290 730 -1270 {lab=2V4}
N 570 -1270 730 -1270 {lab=2V4}
N 310 -1410 330 -1410 {lab=1V65}
N 310 -1470 310 -1410 {lab=1V65}
N 1100 -160 1160 -160 {lab=sub!}
N 1160 -160 1220 -160 {lab=sub!}
N 2460 -160 2710 -160 {lab=sub!}
N 980 -160 1040 -160 {lab=sub!}
N 1460 -160 1520 -160 {lab=sub!}
N 1220 -160 1280 -160 {lab=sub!}
N 1280 -160 1340 -160 {lab=sub!}
N 1340 -160 1400 -160 {lab=sub!}
N 1400 -160 1460 -160 {lab=sub!}
N 280 -1470 280 -1430 {lab=1V65}
N 280 -1470 310 -1470 {lab=1V65}
N 280 -1370 280 -1340 {lab=sub!}
N 540 -1470 540 -1430 {lab=2V4}
N 540 -1470 570 -1470 {lab=2V4}
N 540 -1370 540 -1340 {lab=sub!}
N 2040 -730 2070 -730 {lab=sub!}
N 2130 -730 2150 -730 {lab=2V0}
N 2490 -600 2520 -600 {lab=sub!}
N 2520 -600 2520 -440 {lab=sub!}
N 2460 -440 2520 -440 {lab=sub!}
N 2460 -450 2460 -440 {lab=sub!}
N 2490 -480 2540 -480 {lab=2V0}
N 2540 -640 2540 -480 {lab=2V0}
N 2460 -640 2540 -640 {lab=2V0}
N 2460 -640 2460 -630 {lab=2V0}
N 2460 -440 2460 -160 {lab=sub!}
N 2460 -540 2460 -510 {lab=IFOUT}
N 2460 -570 2460 -540 {lab=IFOUT}
N 2950 -540 2980 -540 {lab=IFOUT}
N 570 -1500 570 -1470 {lab=2V4}
N 2150 -770 2460 -770 {lab=2V0}
N 2460 -770 2460 -640 {lab=2V0}
N 1780 -700 1780 -290 {lab=IFN}
N 1780 -290 2840 -290 {lab=IFN}
N 1880 -700 1880 -400 {lab=IFP}
N 1880 -740 1880 -700 {lab=IFP}
N 2680 -460 2710 -460 {lab=sub!}
N 2650 -300 2710 -300 {lab=sub!}
N 2650 -310 2650 -300 {lab=sub!}
N 2680 -340 2730 -340 {lab=2V0}
N 2730 -500 2730 -340 {lab=2V0}
N 2650 -500 2730 -500 {lab=2V0}
N 2650 -500 2650 -490 {lab=2V0}
N 2650 -400 2650 -370 {lab=IFP}
N 2650 -430 2650 -400 {lab=IFP}
N 1880 -400 2650 -400 {lab=IFP}
N 2870 -350 2900 -350 {lab=sub!}
N 2900 -350 2900 -190 {lab=sub!}
N 2840 -190 2900 -190 {lab=sub!}
N 2840 -200 2840 -190 {lab=sub!}
N 2870 -230 2920 -230 {lab=2V0}
N 2920 -390 2920 -230 {lab=2V0}
N 2840 -390 2920 -390 {lab=2V0}
N 2840 -390 2840 -380 {lab=2V0}
N 2840 -290 2840 -260 {lab=IFN}
N 2840 -320 2840 -290 {lab=IFN}
N 2950 -400 2980 -400 {lab=IFP}
N 2950 -290 2980 -290 {lab=IFN}
N 2710 -460 2710 -300 {lab=sub!}
N 2710 -300 2710 -160 {lab=sub!}
N 2320 -160 2460 -160 {lab=sub!}
N 2150 -160 2320 -160 {lab=sub!}
N 1520 -160 2150 -160 {lab=sub!}
N 210 -160 310 -160 {lab=sub!}
N 410 -160 570 -160 {lab=sub!}
N 2710 -160 2840 -160 {lab=sub!}
N 2840 -190 2840 -160 {lab=sub!}
N 2650 -770 2650 -500 {lab=2V0}
N 2650 -770 2840 -770 {lab=2V0}
N 2840 -770 2840 -390 {lab=2V0}
N 2460 -770 2650 -770 {lab=2V0}
N 2460 -540 2950 -540 {lab=IFOUT}
N 2650 -400 2950 -400 {lab=IFP}
N 2840 -290 2950 -290 {lab=IFN}
N 1840 -1460 2320 -1460 {lab=sub!}
N 210 -160 210 -140 {lab=sub!}
N 310 -160 310 -140 {lab=sub!}
N 410 -160 410 -140 {lab=sub!}
N 310 -160 410 -160 {lab=sub!}
N 410 -80 410 -60 {lab=#net21}
N 310 -60 410 -60 {lab=#net21}
N 310 -80 310 -60 {lab=#net21}
N 210 -60 310 -60 {lab=#net21}
N 210 -80 210 -60 {lab=#net21}
N 310 -60 310 -40 {lab=#net21}
N 90 -160 210 -160 {lab=sub!}
C {title.sym} 160 -30 0 0 {name=l1 author="Ghaith AL SABAGH" lock=true}
C {WILKINSON_LVS.sym} 1380 -950 0 0 {name=x5}
C {MIXER_LVS.sym} 1830 -900 0 1 {name=x6}
C {IFAMP_LVS.sym} 2150 -540 0 0 {name=x7}
C {TRX_LVS.sym} 1280 -2000 3 0 {name=x8 GAIN=3}
C {TRX_LVS.sym} 2450 -2000 1 1 {name=x9 GAIN=3}
C {iopin.sym} 90 -950 2 0 {name=p17 lab=RFIN}
C {iopin.sym} 2150 -770 3 0 {name=p26 lab=2V0}
C {iopin.sym} 570 -1510 3 0 {name=p30 lab=2V4}
C {iopin.sym} 310 -1510 3 0 {name=p31 lab=1V65}
C {iopin.sym} 2980 -540 2 1 {name=p18 lab=IFOUT}
C {sg13g2_pr/bondpad.sym} 980 -100 2 0 {name=X10
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} 1520 -100 2 0 {name=X11
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} 110 -1010 0 0 {name=X15
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} 2950 -600 0 0 {name=X16
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} 370 -1470 1 0 {name=X17
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} 630 -1500 1 0 {name=X18
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} 2210 -730 1 0 {name=X19
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {BALUN_MULT_10GSE_50GD_LVS.sym} 310 -950 0 0 {name=x1}
C {RFAMP_50GD_LVS.sym} 570 -950 0 0 {name=x2}
C {MULT_50GD_150GD_LVS.sym} 830 -950 0 0 {name=x3}
C {RFAMP_150GD_LVS.sym} 1090 -950 0 0 {name=x4}
C {TXAMP_150GD_LVS.sym} 1620 -1660 3 0 {name=x26}
C {RXAMP_150GD_LVS.sym} 2060 -1650 1 0 {name=x27}
C {sg13g2_pr/bondpad.sym} 1040 -100 2 0 {name=X20
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} 1100 -100 2 0 {name=X21
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} 1160 -100 2 0 {name=X22
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} 1220 -100 2 0 {name=X12
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} 1280 -100 2 0 {name=X13
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} 1340 -100 2 0 {name=X14
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} 1400 -100 2 0 {name=X23
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} 1460 -100 2 0 {name=X24
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} 630 -1440 1 0 {name=X25
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} 630 -1380 1 0 {name=X28
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} 630 -1320 1 0 {name=X29
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} 730 -1330 0 0 {name=X30
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} 790 -1330 0 0 {name=X31
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} 2950 -460 0 0 {name=X32
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} 2950 -350 0 0 {name=X33
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} 370 -1410 1 0 {name=X34
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/nmoscl_4.sym} 280 -1400 2 1 {name=D1
model=nmoscl_4
m=2
spiceprefix=X
}
C {sg13g2_pr/nmoscl_4.sym} 2100 -730 3 1 {name=D3
model=nmoscl_4
m=1
spiceprefix=X
}
C {sg13g2_pr/diodevdd_4kv.sym} 2460 -600 0 1 {name=D4
model=diodevdd_4kv
m=1
spiceprefix=X
}
C {sg13g2_pr/diodevss_4kv.sym} 2460 -480 0 1 {name=D5
model=diodevss_4kv
spiceprefix=X
m=1
}
C {sg13g2_pr/nmoscl_4.sym} 540 -1400 2 1 {name=D2
model=nmoscl_4
m=6
spiceprefix=X
}
C {sg13g2_pr/rppd.sym} 1950 -310 1 0 {name=R25
w=2.0e-6
l=71.25e-6
model=rppd
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rppd.sym} 1970 -550 2 0 {name=R24
w=2.0e-6
l=89.64e-6
model=rppd
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rppd.sym} 1700 -670 0 1 {name=R22
w=2.5e-6
l=11.255e-6
model=rppd
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rppd.sym} 1970 -670 0 1 {name=R23
w=2.5e-6
l=11.255e-6
model=rppd
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/diodevdd_4kv.sym} 2650 -460 0 1 {name=D6
model=diodevdd_4kv
m=1
spiceprefix=X
}
C {sg13g2_pr/diodevss_4kv.sym} 2650 -340 0 1 {name=D7
model=diodevss_4kv
spiceprefix=X
m=1
}
C {sg13g2_pr/diodevdd_4kv.sym} 2840 -350 0 1 {name=D8
model=diodevdd_4kv
m=1
spiceprefix=X
}
C {sg13g2_pr/diodevss_4kv.sym} 2840 -230 0 1 {name=D9
model=diodevss_4kv
spiceprefix=X
m=1
}
C {iopin.sym} 2980 -400 2 1 {name=p1 lab=IFP}
C {iopin.sym} 2980 -290 2 1 {name=p2 lab=IFN}
C {sg13g2_pr/sub.sym} 280 -1340 0 0 {name=l2 lab=sub!}
C {sg13g2_pr/sub.sym} 540 -1340 0 0 {name=l3 lab=sub!}
C {sg13g2_pr/sub.sym} 90 -160 1 0 {name=l4 lab=sub!}
C {sg13g2_pr/sub.sym} 2040 -730 1 0 {name=l5 lab=sub!}
C {sg13g2_pr/ptap1.sym} 210 -110 0 0 {name=R[26..35]
model=ptap1
spiceprefix=X
w=80e-6
l=80e-6
spice_ignore=true}
C {sg13g2_pr/ptap1.sym} 310 -110 0 0 {name=R[36..69]
model=ptap1
spiceprefix=X
w=15e-6
l=15e-6
spice_ignore=true}
C {sg13g2_pr/ptap1.sym} 410 -110 0 0 {name=R[70..97]
model=ptap1
spiceprefix=X
w=2e-6
l=2e-6
spice_ignore=true}
C {sg13g2_pr/sub.sym} 310 -40 0 0 {name=l6 lab=sub!
spice_ignore=true}
